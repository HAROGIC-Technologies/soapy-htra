options:
  parameters:
    author: Sebastien Dudek (@FlUxIuS)
    copyright: Penthertz
    generate_options: qt_gui
    id: harogic_simple_rfexplorer
    output_language: python
    title: Harogic Simple RF Explorer
  states: {}

blocks:
- name: antenna
  id: variable
  parameters:
    value: '''External'''
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: 9e3
    step: 1e3
    stop: 9e9
    value: 2437e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Ref level
    start: '-100'
    step: '1'
    stop: '7'
    value: '5'
  states: {}
- name: sample_rate
  id: variable_qtgui_chooser
  parameters:
    label: sample rate
    labels: '[''125000000'',''62500000'',''31250000'', ''15625000'', ''7812500'', ''3906250'', ''1953125'', ''976562.5'',''488281.25'',''244140.625'',''122070.3125'',''61035.15625'']'
    num_opts: '0'
    options: '[125000000,62500000,31250000,15625000,7812500,3906250,1953125,976562.5,488281.25,244140.625,122070.3125,61035.15625]'
    type: int
    value: '1953125'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    ctrlpanel: 'True'
    fc: freq
    fftsize: '1024'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    wintype: window.WIN_FLATTOP
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sample_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    antenna0: antenna
    center_freq0: freq
    comment: |-
      If your device is connected via USB, 
      enter “interface=USB,device=0” in the “Device arguments” field; 
      if it is connected via Ethernet, 
      enter “interface=ETH,ip=192.168.1.100”.
    dc_removal0: 'False'
    dev_args: interface=ETH,ip_address=192.168.1.100
    driver: harogic
    gain0: gain
    samp_rate: sample_rate
    settings0: PREAMP=0,IF_AGC=0
    stream_args: native_format=AUTO
    type: fc32
  states: {}

connections:
- [soapy_custom_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_custom_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1

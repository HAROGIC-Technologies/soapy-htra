options:
  parameters:
    generate_options: qt_gui
    id: FM_demod
    output_language: python
    title: FM Demod
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Center_Frequency
    start: 1e6
    step: '100'
    stop: 3e9
    value: 1e9
  states: {}
- name: decimate_factor
  id: variable
  parameters:
    value: '64'
  states: {}
- name: reference_level
  id: variable_qtgui_range
  parameters:
    label: Reference_Level
    start: '-100'
    step: '1'
    stop: '7'
    value: '-20'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Samp_rate
    orient: QtCore.Qt.Vertical
    start: '3906250'
    step: '1'
    stop: '62500000'
    value: 31250000/4
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '8'
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: '384000'
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.3'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: '384000'
    ctrlpanel: 'True'
    fc: center_freq
    fftsize: '2048'
    gui_hint: 1,0,1,2
    label: Power
    legend: 'False'
    name: Spectrum
    norm_window: 'True'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    units: dBm
    update_time: '0.2'
    wintype: window.WIN_BLACKMAN
    ymax: '15'
    ymin: '-115'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,1,1,1
    legend: 'False'
    name: PvT
    size: '256'
    srate: '48000'
    type: float
    update_time: '0.2'
    ymax: '0.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 0,0,1,1
    label1: Ch-I
    label2: Ch-Q
    name: IQvT
    nconnections: '2'
    size: '512'
    srate: '384000'
    type: float
    update_time: '0.2'
    ylabel: Amplitude(V)
    ymax: '10'
    ymin: '-10'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '15625'
    interp: '768'
    type: ccc
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    antenna0: ANT
    center_freq0: center_freq
    comment: |-
      If your device is connected via USB, 
      enter “interface=USB,device=0” in the “Device arguments” field; 
      if it is connected via Ethernet, 
      enter “interface=ETH,ip=192.168.1.100”.
    dc_removal0: 'False'
    dev_args: interface=USB,device=0
    driver: harogic
    gain0: reference_level
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_time_sink_x_0_0, '1']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', analog_fm_demod_cf_0, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_float_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_custom_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1

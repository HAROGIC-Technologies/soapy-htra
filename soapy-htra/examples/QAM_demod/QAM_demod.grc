options:
  parameters:
    generate_options: qt_gui
    id: QAM
    output_language: python
    title: QAM Demod
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Center_Frequency
    start: '9000'
    step: '100'
    stop: '6300000000'
    value: '1000000000'
  states: {}
- name: decimate_factor
  id: variable
  parameters:
    value: '64'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: reference_level
  id: variable_qtgui_range
  parameters:
    label: Reference_Level
    start: '-50'
    step: '1'
    stop: '23'
    value: '0'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Samp_rate
    start: '976562'
    step: '1'
    stop: '62500000'
    value: 7812500/8
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 0.5e6
  states: {}
- name: variable_constellation_16qam
  id: variable_constellation
  parameters:
    const_points: '[complex(i, q) for q in (-7,-5,-3,-1,1,3,5,7) for i in (-7,-5,-3,-1,1,3,5,7)]'
    normalization: digital.constellation.POWER_NORMALIZATION
    precision: '8'
    sym_map: '[(((s & 7) ^ ((s & 7)>>1) ^ ((s & 7)>>2)) * 8) |(((s>>3) & 7) ^ (((s>>3) & 7)>>1) ^ (((s>>3) & 7)>>2))for s in range(64)]'
    type: 16qam
  states: {}
- name: variable_constellation_64qam
  id: variable_constellation
  parameters:
    const_points: '[complex(i, q) for q in (-7,-5,-3,-1,1,3,5,7) for i in (-7,-5,-3,-1,1,3,5,7)]'
    dims: '1'
    normalization: digital.constellation.POWER_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[(((s & 7) ^ ((s & 7)>>1) ^ ((s & 7)>>2)) * 8) |(((s>>3) & 7) ^ (((s>>3) & 7)>>1) ^ (((s>>3) & 7)>>2))for s in range(64)]'
    type: calcdist
  states: {}
- name: analog_agc2_xx_0_0_1
  id: analog_agc2_xx
  parameters:
    attack_rate: '0.001'
    decay_rate: '0.0001'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '100000'
    type: complex
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '0.707'
    loop_bw: '0.00628'
    max_dev: '1.5'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_1_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: variable_constellation_16qam
    damping: '0.707'
    loop_bw: 0.0628*0.1
    max_dev: '1.5'
    nfilters: '128'
    osps: '1'
    pfb_mf_taps: '[]'
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    Constellation_Object: variable_constellation_16qam
    Damping_Factor: '1'
    Loop_BandWidth: '0.0314'
    _source_code: |
      import numpy as np
      from gnuradio import gr, digital

      class OptimizedDDPLL(gr.sync_block):
          def __init__(self, Loop_BandWidth=0.01, Damping_Factor=1, Constellation_Object=digital.bpsk_constellation()):
              gr.sync_block.__init__(
                  self,
                  name='DDPLL',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              
              self.Loop_BandWidth = Loop_BandWidth
              self.Damping_Factor = Damping_Factor
              self.Constellation_Object = Constellation_Object

       
              if hasattr(Constellation_Object, 'points'):
                  points = Constellation_Object.points()
              else:
                  points = Constellation_Object
                  

              self.real_levels = np.unique(np.real(points))
              self.imag_levels = np.unique(np.imag(points))
              

              self.phase = 0.0
              self.freq = 0.0
              self.update_loop_coefficients()
              

              self.max_freq_step = 0.05

          def update_loop_coefficients(self):
              bw = self.Loop_BandWidth
              damp = self.Damping_Factor
              K = 2.0
              denom = 1.0 + 2.0 * damp * bw + bw * bw
              self.alpha = (4.0 * damp * bw * K) / denom
              self.beta = (4.0 * bw * bw * K) / denom

          def fast_decision(self, symbol):
              real_decision = self.real_levels[np.argmin(np.abs(self.real_levels - np.real(symbol)))]
              imag_decision = self.imag_levels[np.argmin(np.abs(self.imag_levels - np.imag(symbol)))]
              return real_decision + 1j * imag_decision

          def work(self, input_items, output_items):
              inputs = input_items[0]
              outputs = output_items[0]
              
              for i in range(len(inputs)):
            
                  rotated = inputs[i] * np.exp(-1j * self.phase)

                  decision = self.fast_decision(rotated)

                  if abs(decision) > 1e-10:
                      error = np.angle(rotated * np.conj(decision))
                      error = max(min(error, np.pi/4), -np.pi/4)
                  else:
                      error = 0.0
                  

                  freq_update = self.beta * error
                  if abs(freq_update) > self.max_freq_step:
                      freq_update = np.sign(freq_update) * self.max_freq_step
                  
                  self.freq += freq_update
                  self.phase += self.freq + self.alpha * error
                  
                  if self.phase > np.pi:
                      self.phase -= 2 * np.pi
                  elif self.phase < -np.pi:
                      self.phase += 2 * np.pi
                  
                  outputs[i] = rotated
              
              return len(outputs)
  states: {}
- name: qtgui_const_sink_x_0_1_0_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 0,1,1,1
    legend: 'False'
    name: Constellation
    size: '256'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '10000000'
    fc: center_freq
    fftsize: '2048'
    gui_hint: 1,0,1,2
    label: Power
    legend: 'False'
    name: Spectrum
    type: complex
    units: dBm
    update_time: '0.2'
    ymin: '-160'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 0,0,1,1
    label1: Ch-I
    label2: Ch-Q
    name: IQvT
    nconnections: '2'
    size: '256'
    srate: samp_rate
    type: float
    ylabel: Amplitude(V)
  states: {}
- name: rational_resampler_xxx_0_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '125'
    fbw: '0.4'
    interp: '128'
    type: ccc
  states: {}
- name: root_raised_cosine_filter_0_0_1
  id: root_raised_cosine_filter
  parameters:
    alpha: excess_bw
    decim: '1'
    gain: '1'
    ntaps: '22'
    samp_rate: symbol_rate*sps
    sym_rate: symbol_rate
    type: fir_filter_ccf
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    antenna0: ANT
    center_freq0: center_freq
    dc_removal0: 'False'
    driver: harogic
    gain0: '5'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_agc2_xx_0_0_1, '0', digital_symbol_sync_xx_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_time_sink_x_0, '1']
- [blocks_skiphead_0, '0', epy_block_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_skiphead_0, '0']
- [epy_block_0, '0', qtgui_const_sink_x_0_1_0_0_0, '0']
- [rational_resampler_xxx_0_0_1, '0', root_raised_cosine_filter_0_0_1, '0']
- [root_raised_cosine_filter_0_0_1, '0', analog_agc2_xx_0_0_1, '0']
- [soapy_custom_source_0, '0', blocks_complex_to_float_0, '0']
- [soapy_custom_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_custom_source_0, '0', rational_resampler_xxx_0_0_1, '0']

metadata:
  file_format: 1

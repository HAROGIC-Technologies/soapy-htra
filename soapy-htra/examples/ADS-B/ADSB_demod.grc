options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: adsb_rx
    output_language: python
    title: ADSB Demod
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Center_Frequency
    start: '9000'
    step: '100'
    stop: '6300000000'
    value: '1090000000'
  states: {}
- name: fs
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: reference_level
  id: variable_qtgui_range
  parameters:
    label: Reference_Level
    start: '-100'
    step: '1'
    stop: '23'
    value: '-50'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Sample_rate
    start: '976562'
    step: '1'
    stop: '62500000'
    value: '3906250'
  states: {}
- name: threshold
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,1,1,1
    label: Detection Threshold
    type: real
    value: '1e-8'
  states: {}
- name: adsb_decoder_0_0
  id: adsb_decoder
  parameters:
    error_corr: '"None"'
    msg_filter: '"Extended Squitter Only"'
    print_level: '"Verbose"'
  states: {}
- name: adsb_demod_0_0
  id: adsb_demod
  parameters:
    fs: fs
  states: {}
- name: adsb_framer_1_0
  id: adsb_framer
  parameters:
    fs: fs
    threshold: threshold
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: threshold
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,0,1,2
    label1: ''
    label2: ''
    legend: 'False'
    marker1: '0'
    nconnections: '2'
    size: '300'
    srate: fs
    tr_delay: '1.25e-6'
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"burst"'
    type: float
    update_time: '0.2'
    ymax: '2e-8'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: ''
    legend: 'False'
    marker1: '0'
    size: int(fs*150e-6)
    srate: int(fs)
    tr_delay: '1.25e-6'
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"burst"'
    type: float
    update_time: 1.0/100.0
    ymin: '0'
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '125'
    fbw: '0.4'
    interp: '64'
    type: ccc
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    antenna0: ANT
    bandwidth0: '3000000'
    center_freq0: center_freq
    comment: |-
      If your device is connected via USB, 
      enter “interface=USB,device=0” in the “Device arguments” field; 
      if it is connected via Ethernet, 
      enter “interface=ETH,ip=192.168.1.100”.
    dc_removal0: 'False'
    dev_args: interface=USB,device=0
    driver: harogic
    gain0: '40'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: zeromq_pub_msg_sink_0_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:5001
    timeout: '10'
  states: {}

connections:
- [adsb_decoder_0_0, decoded, zeromq_pub_msg_sink_0_0, in]
- [adsb_demod_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [adsb_demod_0_0, demodulated, adsb_decoder_0_0, demodulated]
- [adsb_framer_1_0, '0', adsb_demod_0_0, '0']
- [analog_const_source_x_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_complex_to_mag_squared_0_0, '0', adsb_framer_1_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [soapy_custom_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1

options:
  parameters:
    author: Sebastien Dudek (@FlUxIuS)
    copyright: Penthertz
    generate_options: qt_gui
    id: harogic_simple_rfexplorer
    output_language: python
    title: Harogic Simple RF Explorer
  states: {}

blocks:
- name: antenna
  id: variable
  parameters:
    value: '''External'''
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: 9e3
    step: 1e3
    stop: 9e9
    value: 98.4e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Ref level
    start: '-100'
    step: '1'
    stop: '7'
    value: '-30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(samprates)
  states: {}
- name: samprates
  id: variable_qtgui_chooser
  parameters:
    label: Sample rate
    labels: '[''122880000'', ''61440000'', ''30720000'', ''15360000'', ''7680000'', ''3840000'', ''1920000'', ''960000'']'
    num_opts: '0'
    options: '[122880000, 61440000, 30720000, 15360000, 7680000, 3840000, 1920000, 960000]'
    type: int
    value: '61440000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: freq
    fftsize: '1024'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    antenna0: antenna
    center_freq0: freq
    dc_removal0: 'False'
    driver: harogic
    gain0: gain
    samp_rate: samp_rate
    settings0: PREAMP=0,IF_AGC=0
    stream_args: native_format=AUTO
    type: fc32
  states: {}

connections:
- [soapy_custom_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_custom_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
